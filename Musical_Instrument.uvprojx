# Keil uVision project Musical_Instrument.uvprojx, settings and files
target Musical_Instrument (6070000::V6.7::.\ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: CPUTYPE("Cortex-M3")
  output: Musical_Instrument
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: DEVICE_DEBUG_AWARENESS=1 __MBED_CMSIS_RTOS_CM DEVICE_PORTINOUT=1 TARGET_LIKE_MBED DEVICE_USBDEVICE=1 DEVICE_WATCHDOG=1 DEVICE_PORTIN=1 DEVICE_ETHERNET=1 DEVICE_EMAC=1 TARGET_M3 DEVICE_SPISLAVE=1 __CMSIS_RTOS MBED_RAM1_SIZE=0x8000 DEVICE_RTC=1 DEVICE_PWMOUT=1 TARGET_LIKE_CORTEX_M3 DEVICE_I2C=1 TARGET_NXP_EMAC DEVICE_RESET_REASON=1 MULADDC_CANNOT_USE_R7 __MBED__=1 TARGET_LPC176X DEVICE_SERIAL=1 DEVICE_FLASH=1 DEVICE_STDIO_MESSAGES=1 MBED_RAM_START=0x10000000 MBED_ROM_SIZE=0x80000 MBED_ROM_START=0x0 MBED_BUILD_TIMESTAMP=1636677533.7423463 DEVICE_SLEEP=1 DEVICE_ANALOGIN=1 TARGET_RELEASE DEVICE_INTERRUPTIN=1 TARGET_LPC1768 TOOLCHAIN_ARM_STD TOOLCHAIN_ARM TARGET_MBED_LPC1768 DEVICE_SEMIHOST=1 TARGET_LPCTarget TARGET_CORTEX MBED_RAM_SIZE=0x8000 DEVICE_SERIAL_FC=1 DEVICE_CAN=1 __ASSERT_MSG DEVICE_MPU=1 DEVICE_PORTOUT=1 MBED_MINIMAL_PRINTF __CORTEX_M3 TARGET_NXP ARM_MATH_CM3 DEVICE_USTICKER=1 TARGET_CORTEX_M DEVICE_ANALOGOUT=1 MBED_RAM1_START=0x2007c000 TOOLCHAIN_ARMC6 DEVICE_I2CSLAVE=1 DEVICE_LOCALFILESYSTEM=1 DEVICE_SPI=1 TARGET_NAME=LPC1768 MBED_TRAP_ERRORS_ENABLED=1
  c misc: -fno-rtti -Wno-armcc-pragma-push-pop -fno-exceptions -Wno-armcc-pragma-anon-unions -fshort-wchar -Wno-deprecated-register -fno-c++-static-destructors -Wno-reserved-user-defined-literal -mcpu=cortex-m3 -fdata-sections --target=arm-arm-none-eabi -fshort-enums -c -mthumb -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;4DGL-uLCD-SE;PinDetect;mbed;mbed/TARGET_LPC1768;mbed/TARGET_LPC1768/TARGET_NXP;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-DARM_MATH_CM3,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: --predefine="-DMBED_RAM_START=0x10000000" --predefine="-DMBED_RAM1_START=0x2007c000" --predefine="-DMBED_ROM_SIZE=0x80000" --predefine="-DMBED_RAM1_SIZE=0x8000" --legacyalign --inline --keep=os_cb_sections --predefine="-DMBED_RAM_SIZE=0x8000" --predefine="-DMBED_BOOT_STACK_SIZE=4096" --show_full_path --predefine="-DXIP_ENABLE=0" --any_contingency --cpu=Cortex-M3 --predefine="-DMBED_ROM_START=0x0"
  group 4DGL-uLCD-SE
    4DGL-uLCD-SE/: uLCD_4DGL.h uLCD_4DGL_Graphics.cpp uLCD_4DGL_main.cpp uLCD_4DGL_Media.cpp uLCD_4DGL_Text.cpp
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o ethernet_api.o flash_api.o gpio_api.o gpio_irq_api.o i2c_api.o mbed.ar mbed_board.o mbed_retarget.o mbed_sdk_boot.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o startup_LPC17xx.o sys.o system_LPC17xx.o us_ticker.o
    mbed/TARGET_LPC1768/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device/: cmsis.h cmsis_nvic.h LPC17xx.h system_LPC17xx.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: device.h PinNames.h reserved_pins.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/: gpio_object.h objects.h PeripheralNames.h PortNames.h
    mbed/: mbed.h
    mbed/TARGET_LPC1768/TARGET_NXP/: mbed_rtx.h
  group Musical_Instrument
    ./: main.cpp mbed_config.h MMA8452.cpp MMA8452.h Speaker.h
  group PinDetect
    PinDetect/: ChangeLog.h example.h PinDetect.h
